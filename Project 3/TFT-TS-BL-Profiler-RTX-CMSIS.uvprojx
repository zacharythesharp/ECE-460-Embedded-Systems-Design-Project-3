# Keil uVision project TFT-TS-BL-Profiler-RTX-CMSIS.uvprojx, settings and files
target TFT LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TFT-TS-BL-Profiler-RTX-CMSIS
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --fpmode=fast -g
  c include: .\Include;.\Source\LCD;.\Source\Profiler
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  link misc: --debug
  group Source
    ./Source/: delay.c DMA.c I2C.c LEDs.c main.c MMA8451.c sound.c threads.c timers.c debug.c control.c FX.c my_data.h
  group LCD
    ./Source/LCD/: lucida_8x13.c lucida_12x19.c lucida_20x31.c LCD_graphics.c LCD_text.c T6963.c touchscreen.c ST7789.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
target Mono LCD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: as above
  output: TFT-TS-BL-Profiler-RTX-CMSIS
  AfterMake: Scripts\update_regions_MDK.bat
  AfterMake: Scripts\find_sizes.bat !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --fpmode=fast
  c include: .\Include;.\Source\LCD;.\Source\Profiler
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 2.5.0
